# Keil uVision project Experiment.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S9B92 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Experiment
  c flags: wLevel=2
  c define: rvmdk PART_LM3S9B92 TARGET_IS_TEMPEST_RC3
  c include: ..;..\..\..;..\..\..\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\rvmdk\Experiment.sct
  link misc: --entry Reset_Handler
  group Include
    ./: HardwareLibrary.h LuminaryDriverLibrary.h
  group Source Group 1
    ./: Startup.s main.c GPIODriverConfigure.c SysCtlConfigure.c SysTickConfigure.c TimerConfigure.c WatchDogConfigure.c UARTConfigure.c I2CConfigure.c NixieTubeConfigure.c PWMConfigure.c LCDConfigure.c LCDDisplay.c ADCConfigure.c
  group Interrupt Service Routine
    ./: SysTickISR.c TimerISR.c UARTISR.c I2CISR.c ADCISR.c
  group Libraries
    ../../driverlib/rvmdk/: driverlib.lib
    ../../grlib/rvmdk/: grlib.lib
  group Document
    ./: readme.txt
